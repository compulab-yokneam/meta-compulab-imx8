RPROVIDES_${PN} = "libvpu"

