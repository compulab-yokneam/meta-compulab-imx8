DEPENDS_append = " wayland"
