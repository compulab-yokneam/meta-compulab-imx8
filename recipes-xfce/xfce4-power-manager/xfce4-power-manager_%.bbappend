# A build conflict error patch
RDEPENDS_${PN}_remove = "networkmanager"
RDEPENDS_remove = "networkmanager"
